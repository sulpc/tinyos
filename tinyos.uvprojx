# Keil uVision project tinyos.uvprojx, settings and files
target project (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: appfw +hex
  c flags: Optim=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\code\bsp;.\code\bsp\CMSIS\CM3\CoreSupport;.\code\bsp\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\code\tinyos\core;.\code\tinyos;.\code\utils;.\code\utils\cli;.\code\utils\heap;.\code\utils\log;.\code\utils\queue;.\code\utils\ringbuffer;.\code\utils\time
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ./code/app/: main_os.c
  group bsp
    ./code/bsp/: bsp.c
    ./code/bsp/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
    ./code/bsp/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group tinyos
    ./code/tinyos/core/: tos_cond.c tos_core.c tos_mutex.c
    ./code/tinyos/ports/cm3/: tos_cpu_c.c
    ./code/tinyos/ports/cm3/arm/: tos_cpu_s.s
  group utils
    ./code/utils/cli/: util_cli.c
    ./code/utils/heap/: util_heap.c
    ./code/utils/log/: util_log.c
    ./code/utils/ringbuffer/: util_ringbuffer.c
    ./code/utils/time/: util_time.c
